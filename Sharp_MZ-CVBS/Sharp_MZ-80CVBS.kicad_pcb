# Repository BrettHallen/Sharp-MZ-80B (continued)

## KiCad design Sharp_MZ-80GM/Sharp_MZ-80GM.kicad_pcb (continued)

Board: 2 copper layers, 165.0 x 95.0 mm, 42 parts (0 on the bottom side), 96 nets.

File Sharp_MZ-80GM/pcbway_production/2026-02-15-21-03-40/Sharp_MZ-80GM.kicad_pcb_bom.csv:

Designator,Quantity,Value,Footprint,Package,MPN,DNP,Mount_Type,Description
"C1, C10, C11, C12, C13, C14, C5, C6, C8",9,100nF,C_Disc_D3.8mm_W2.6mm_P2.50mm,,,,tht,Unpolarized capacitor
C15,1,220pF,C_Disc_D3.8mm_W2.6mm_P2.50mm,,,,tht,Unpolarized capacitor
C7,1,470pF,C_Disc_D3.8mm_W2.6mm_P2.50mm,,,,tht,Unpolarized capacitor
C9,1,100µF,CP_Radial_D5.0mm_P2.50mm,,,,tht,Polarized capacitor
CN1,1,To CPU Board,PinHeader_2x20_P2.54mm_Vertical,,,,tht,"Generic connector, double row, 02x20, odd/even pin numbering scheme (row 1 odd numbers, row 2 even numbers), script generated (kicad-library-utils/schlib/autogen/connector/)"
CN2,1,To CPU Board,PinHeader_2x05_P2.54mm_Vertical,,,,tht,"Generic connector, double row, 02x05, odd/even pin numbering scheme (row 1 odd numbers, row 2 even numbers), script generated (kicad-library-utils/schlib/autogen/connector/)"
CN3,1,To MZ-80GMK,PinHeader_2x05_P2.54mm_Horizontal,,,,tht,"Generic connector, double row, 02x05, odd/even pin numbering scheme (row 1 odd numbers, row 2 even numbers), script generated (kicad-library-utils/schlib/autogen/connector/)"
IC1,1,62256,DIP-28_W15.24mm,,,,tht,"256K (32K x 8) Static RAM, 70ns, DIP-28"
"IC10, IC11, IC12",3,74LS93,DIP-14_W7.62mm,,,,tht,Divide by 2 & 8 counter
IC13,1,74LS245,DIP-20_W7.62mm,,,,tht,"Octal BUS Transceivers, 3-State outputs"
IC14,1,74LS165,DIP-16_W7.62mm,,,,tht,"Shift Register 8-bit, parallel load"
IC15,1,74LS175,DIP-16_W7.62mm,,,,tht,"4-bit D Flip-Flop, reset"
IC16,1,74LS04,DIP-14_W7.62mm,,,,tht,Hex Inverter
IC17,1,74LS107,DIP-14_W7.62mm,,,,tht,"Dual JK Flip-Flop, reset"
"IC18, IC20",2,74LS32,DIP-14_W7.62mm,,,,tht,Quad 2-input OR
IC19,1,74LS08,DIP-14_W7.62mm,,,,tht,Quad And2
IC21,1,74LS00,DIP-14_W7.62mm,,,,tht,quad 2-input NAND gate
"IC5, IC6, IC7, IC8",4,74LS157,DIP-16_W7.62mm,,,,tht,Quad 2 to 1 line Multiplexer
"R1, R2, R3, R4",4,1KΩ,R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal,,,,tht,Resistor
R5,1,47Ω,R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal,,,,tht,Resistor
R6,1,100Ω,R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal,,,,tht,Resistor

## KiCad design Keyboard/Sharp_MZ-80B_Keyboard.kicad_pcb

File Keyboard/README.md:

# Sharp MZ-80B Keyboard
The keyboard uses three types of Futuba key switches:
- Most keys are Futuba MD-4P-CS with orange base
- Three illuminated keys (カナ RVS, GRPH and SFT LOCK) are Futuba MD-7 with black body & base (?)
- SPACE bar is white body/cream base
- Function, cursor and cassette controls are 12mm tactile switched with 7mm height

Key caps
- 1.0u = 66
- 2.0u = 1
- 1.5u = 1
- 1.75u = 2
- 2.25u = 2
- 6.25u = 1
- 12mm tactile = 18
- Total = 92

Parts:
H1, H2, H3, H4, H5: MountingHole; MountingHole_4.3mm_M4
H6, H7, H8, H9: MountingHole; MountingHole_3.2mm_M3
J1: Tape Controls; PinHeader_1x06_P2.54mm_Vertical
J2: Keyboard Matrix; PinHeader_1x20_P2.54mm_Vertical
J3: LEDs; PinHeader_1x04_P2.54mm_Vertical
SW1: CMT_EJECT; SW_PUSH-12mm
SW2: CMT_FF; SW_PUSH-12mm
SW3: CMT_REW; SW_PUSH-12mm
SW4: CMT_STOP; SW_PUSH-12mm
SW5: ]; Futuba MD-4P
SW6: CLR HOME; Futuba MD-4P
SW7: INST DEL; Futuba MD-4P
SW8: 8; Futuba MD-4P
SW9: 9; Futuba MD-4P
SW10: COLON; Futuba MD-4P
SW11: SEMI COLON; Futuba MD-4P
SW12: -; Futuba MD-4P
SW13: @; Futuba MD-4P
SW14: [; Futuba MD-4P
SW15: ZERO; Futuba MD-4P
SW16: 1; Futuba MD-4P
SW17: 2; Futuba MD-4P
SW18: 3; Futuba MD-4P
SW19: 4; Futuba MD-4P
SW20: 5; Futuba MD-4P
SW21: 6; Futuba MD-4P
SW22: 7; Futuba MD-4P
SW23: X; Futuba MD-4P
SW24: Y; Futuba MD-4P
SW25: Z; Futuba MD-4P
SW26: ^; Futuba MD-4P
SW27: \; Futuba MD-4P
SW28: ?; Futuba MD-4P
SW29: DOT; Futuba MD-4P
SW30: COMMA; Futuba MD-4P
SW31: P; Futuba MD-4P
SW32: Q; Futuba MD-4P
SW33: R; Futuba MD-4P
SW34: S; Futuba MD-4P
SW35: T; Futuba MD-4P
SW36: U; Futuba MD-4P
SW37: V; Futuba MD-4P
SW38: W; Futuba MD-4P
SW39: I; Futuba MD-4P
SW40: H; Futuba MD-4P
SW41: J; Futuba MD-4P
SW42: K; Futuba MD-4P
SW43: L; Futuba MD-4P
SW44: M; Futuba MD-4P
SW45: N; Futuba MD-4P
SW46: O; Futuba MD-4P
SW47: /; Futuba MD-4P
SW48: A; Futuba MD-4P
SW49: B; Futuba MD-4P
SW50: C; Futuba MD-4P
SW51: D; Futuba MD-4P
SW52: E; Futuba MD-4P
SW53: F; Futuba MD-4P
SW54: G; Futuba MD-4P
SW55: TAB; Futuba MD-4P
SW56: SPACE; Futuba MD-4P
SW57: CR; Futuba MD-4P
SW58: UP; SW_PUSH-12mm
SW59: DOWN; SW_PUSH-12mm
SW60: LEFT; SW_PUSH-12mm
SW61: RIGHT; SW_PUSH-12mm
SW62: BREAK; Futuba MD-4P
SW63: GRPH; Futuba MD-7
SW64: NP 0; Futuba MD-4P
SW65: NP 1; Futuba MD-4P
SW66: NP 2; Futuba MD-4P
SW67: NP 3; Futuba MD-4P
SW68: NP 4; Futuba MD-4P
SW69: NP 5; Futuba MD-4P
SW70: NP 6; Futuba MD-4P
SW71: NP 7; Futuba MD-4P
SW72: SFT LOCK; Futuba MD-7
SW73: F9; SW_PUSH-12mm
SW74: F10; SW_PUSH-12mm
SW75: NP 8; Futuba MD-4P
SW76: NP 9; Futuba MD-4P
SW77: NP 00; Futuba MD-4P
SW78: NP DOT; Futuba MD-4P
SW79: NP PLUS; Futuba MD-4P
SW80: NP MINUS; Futuba MD-4P
SW81: F1; SW_PUSH-12mm
SW82: F2; SW_PUSH-12mm
SW83: F3; SW_PUSH-12mm
SW84: F4; SW_PUSH-12mm
SW85: F5; SW_PUSH-12mm
SW86: F6; SW_PUSH-12mm
SW87: F7; SW_PUSH-12mm
SW88: F8; SW_PUSH-12mm
SW89: カナ RVS; Futuba MD-7
SW90: RH SHIFT; Futuba MD-4P
SW91: LH_SHIFT; Futuba MD-4P
SW92: NP ENT; Futuba MD-4P

Connections:
CMT_COMMON: J1.6, SW1.2, SW2.2, SW3.2
CMT_EJECT: J1.1, SW1.1
CMT_FF: J1.5, SW2.1
CMT_REW: J1.4, SW3.1
CMT_STOP1: J1.2, SW4.1
CMT_STOP2: J1.3, SW4.2
COL0: J2.1, SW5.1, SW8.1, SW15.1, SW23.1, SW31.1, SW39.1, SW47.1, SW55.1, SW63.1, SW64.1, SW73.1, SW81.1
COL1: J2.2, SW9.1, SW16.1, SW24.1, SW32.1, SW40.1, SW48.1, SW56.1, SW65.1, SW72.1, SW74.1, SW82.1
COL2: J2.3, SW6.1, SW10.1, SW17.1, SW25.1, SW33.1, SW41.1, SW49.1, SW57.1, SW66.1, SW75.1, SW83.1, SW90.1, SW91.1, SW92.1
COL3: J2.4, SW7.1, SW11.1, SW18.1, SW26.1, SW34.1, SW42.1, SW50.1, SW58.1, SW67.1, SW76.1, SW84.1, SW89.1
COL4: J2.5, SW12.1, SW19.1, SW27.1, SW35.1, SW43.1, SW51.1, SW59.1, SW68.1, SW77.1, SW85.1
COL5: J2.6, SW13.1, SW20.1, SW28.1, SW36.1, SW44.1, SW52.1, SW60.1, SW69.1, SW78.1, SW86.1
COL6: J2.7, SW14.1, SW21.1, SW29.1, SW37.1, SW45.1, SW53.1, SW61.1, SW70.1, SW79.1, SW87.1
COL7: J2.8, SW22.1, SW30.1, SW38.1, SW46.1, SW54.1, SW62.1, SW71.1, SW80.1, SW88.1
GRPH_LED: J3.3, SW63.3 (K), SW72.3 (K)
LED_COMMON: J3.1, SW63.2, SW72.2, SW89.2
ROW0: J2.9, SW63.4 (A), SW72.4 (A), SW89.4 (A), SW90.2, SW91.2
ROW1: J2.10, SW5.2, SW6.2, SW7.2
ROW2: J2.11, SW8.2, SW9.2, SW10.2, SW11.2, SW12.2, SW13.2, SW14.2
ROW3: J2.12, SW15.2, SW16.2, SW17.2, SW18.2, SW19.2, SW20.2, SW21.2, SW22.2
ROW4: J2.13, SW23.2, SW24.2, SW25.2, SW26.2, SW27.2, SW28.2, SW29.2, SW30.2
ROW5: J2.14, SW31.2, SW32.2, SW33.2, SW34.2, SW35.2, SW36.2, SW37.2, SW38.2
ROW6: J2.15, SW39.2, SW40.2, SW41.2, SW42.2, SW43.2, SW44.2, SW45.2, SW46.2
ROW7: J2.16, SW47.2, SW48.2, SW49.2, SW50.2, SW51.2, SW52.2, SW53.2, SW54.2
ROW8: J2.17, SW55.2, SW56.2, SW57.2, SW58.2, SW59.2, SW60.2, SW61.2, SW62.2, SW92.2
ROW9: J2.18, SW64.2, SW65.2, SW66.2, SW67.2, SW68.2, SW69.2, SW70.2, SW71.2
ROW10: J2.19, SW73.2, SW74.2, SW75.2, SW76.2, SW77.2, SW78.2, SW79.2, SW80.2
ROW11: J2.20, SW81.2, SW82.2, SW83.2, SW84.2, SW85.2, SW86.2, SW87.2, SW88.2
SFT_LOCK_LED: J3.4
カナ_RVS_LED: J3.2, SW89.3 (K)

Notes on the sheet:
Cassette Controls
Key Cap Sizes カナ RVS: 1.0u with LED BREAK: 1.5u GRAPH: 1.5u with LED SFT LOCK: 1.75u with LED CR: 1.75u SHIFT: 2.25u (x2) ENT: 2.0u SPACE: 8.0u All others are 1.0u Most key switches are Futuba MD-4P-CS type. Illuminated are Futuba MD-7 (?) Cursor, cassette/CMT, Function keys are 12mm tactile with 7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

Board: 2 copper layers, 394.5 x 161.0 mm, 104 parts (0 on the bottom side), 29 nets.

## KiCad design Sharp_MZ-80B_RAM_III_IV_Expansion/Sharp_MZ-80B_RAM_III_IV_Expansion.kicad_pcb

Parts:
C1, C2, C3, C4, C5, C6, C7, C8, C9, C10, C11, C12, C13, C14, C15, C16: 100µF; C_Disc_D3.4mm_W2.1mm_P2.50mm
CN1: Address & Power; PinHeader_1x20_P2.54mm_Vertical
CN2: Data; PinHeader_1x20_P2.54mm_Vertical
R1, R2, R3, R4: 1KΩ; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
U1, U2, U3, U4, U5, U6, U7, U8, U9, U10, U11, U12, U13, U14, U15, U16: MK4116N; DIP-16_W7.62mm

Connections:
/A_{0}: CN1.11, U1.5 (A0), U2.5 (A0), U3.5 (A0), U4.5 (A0), U5.5 (A0), U6.5 (A0), U7.5 (A0), U8.5 (A0), U9.5 (A0), U10.5 (A0), U11.5 (A0), U12.5 (A0), U13.5 (A0), U14.5 (A0), U15.5 (A0), U16.5 (A0)
/A_{1}: CN1.12, U1.7 (A1), U2.7 (A1), U3.7 (A1), U4.7 (A1), U5.7 (A1), U6.7 (A1), U7.7 (A1), U8.7 (A1), U9.7 (A1), U10.7 (A1), U11.7 (A1), U12.7 (A1), U13.7 (A1), U14.7 (A1), U15.7 (A1), U16.7 (A1)
/A_{2}: CN1.13, U1.6 (A2), U2.6 (A2), U3.6 (A2), U4.6 (A2), U5.6 (A2), U6.6 (A2), U7.6 (A2), U8.6 (A2), U9.6 (A2), U10.6 (A2), U11.6 (A2), U12.6 (A2), U13.6 (A2), U14.6 (A2), U15.6 (A2), U16.6 (A2)
/A_{3}: CN1.14, U1.12 (A3), U2.12 (A3), U3.12 (A3), U4.12 (A3), U5.12 (A3), U6.12 (A3), U7.12 (A3), U8.12 (A3), U9.12 (A3), U10.12 (A3), U11.12 (A3), U12.12 (A3), U13.12 (A3), U14.12 (A3), U15.12 (A3), U16.12 (A3)
/A_{4}: CN1.15, U1.11 (A4), U2.11 (A4), U3.11 (A4), U4.11 (A4), U5.11 (A4), U6.11 (A4), U7.11 (A4), U8.11 (A4), U9.11 (A4), U10.11 (A4), U11.11 (A4), U12.11 (A4), U13.11 (A4), U14.11 (A4), U15.11 (A4), U16.11 (A4)
/A_{5}: CN1.16, U1.10 (A5), U2.10 (A5), U3.10 (A5), U4.10 (A5), U5.10 (A5), U6.10 (A5), U7.10 (A5), U8.10 (A5), U9.10 (A5), U10.10 (A5), U11.10 (A5), U12.10 (A5), U13.10 (A5), U14.10 (A5), U15.10 (A5), U16.10 (A5)
/A_{6}: CN1.17, U1.13 (A6), U2.13 (A6), U3.13 (A6), U4.13 (A6), U5.13 (A6), U6.13 (A6), U7.13 (A6), U8.13 (A6), U9.13 (A6), U10.13 (A6), U11.13 (A6), U12.13 (A6), U13.13 (A6), U14.13 (A6), U15.13 (A6), U16.13 (A6)
/DIN_{0}: CN2.1, U1.2 (DIN), U9.2 (DIN)
/DIN_{1}: CN2.4, U2.2 (DIN), U10.2 (DIN)
/DIN_{2}: CN2.6, U3.2 (DIN), U11.2 (DIN)
/DIN_{3}: CN2.8, U4.2 (DIN), U12.2 (DIN)
/DIN_{4}: CN2.11, U5.2 (DIN), U13.2 (DIN)
/DIN_{5}: CN2.14, U6.2 (DIN), U14.2 (DIN)
/DIN_{6}: CN2.16, U7.2 (DIN), U15.2 (DIN)
/DIN_{7}: CN2.18, U8.2 (DIN), U16.2 (DIN)
/DOUT_{0}: CN2.2, U1.14 (DOUT), U9.14 (DOUT)
/DOUT_{1}: CN2.5, U2.14 (DOUT), U10.14 (DOUT)
/DOUT_{2}: CN2.7, U3.14 (DOUT), U11.14 (DOUT)
/DOUT_{3}: CN2.9, U4.14 (DOUT), U12.14 (DOUT)
/DOUT_{4}: CN2.12, U5.14 (DOUT), U13.14 (DOUT)
/DOUT_{5}: CN2.15, U6.14 (DOUT), U14.14 (DOUT)
/DOUT_{6}: CN2.17, U7.14 (DOUT), U15.14 (DOUT)
/DOUT_{7}: CN2.19, U8.14 (DOUT), U16.14 (DOUT)
/~CAS_{III}: CN1.18, R1.2, U9.15 (~CAS), U10.15 (~CAS), U11.15 (~CAS), U12.15 (~CAS), U13.15 (~CAS), U14.15 (~CAS), U15.15 (~CAS), U16.15 (~CAS)
/~CAS_{IV}: CN1.9, R3.2, U1.15 (~CAS), U2.15 (~CAS), U3.15 (~CAS), U4.15 (~CAS), U5.15 (~CAS), U6.15 (~CAS), U7.15 (~CAS), U8.15 (~CAS)
/~RAS_{III}: CN1.19, R2.2, U9.4 (~RAS), U10.4 (~RAS), U11.4 (~RAS), U12.4 (~RAS), U13.4 (~RAS), U14.4 (~RAS), U15.4 (~RAS), U16.4 (~RAS)
/~RAS_{IV}: CN1.10, R4.2, U1.4 (~RAS), U2.4 (~RAS), U3.4 (~RAS), U4.4 (~RAS), U5.4 (~RAS), U6.4 (~RAS), U7.4 (~RAS), U8.4 (~RAS)
/~WRITE: CN1.20, U1.3 (~WRITE), U2.3 (~WRITE), U3.3 (~WRITE), U4.3 (~WRITE), U5.3 (~WRITE), U6.3 (~WRITE), U7.3 (~WRITE), U8.3 (~WRITE), U9.3 (~WRITE), U10.3 (~WRITE), U11.3 (~WRITE), U12.3 (~WRITE), U13.3 (~WRITE), U14.3 (~WRITE), U15.3 (~WRITE), U16.3 (~WRITE)
V_{BB}: CN1.5, CN1.6, U1.1 (VBB), U2.1 (VBB), U3.1 (VBB), U4.1 (VBB), U5.1 (VBB), U6.1 (VBB), U7.1 (VBB), U8.1 (VBB), U9.1 (VBB), U10.1 (VBB), U11.1 (VBB), U12.1 (VBB), U13.1 (VBB), U14.1 (VBB), U15.1 (VBB), U16.1 (VBB)
V_{CC}: C1.1, C2.1, C3.1, C4.1, C5.1, C6.1, C7.1, C8.1, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, CN1.3, CN1.4, R1.1, R2.1, R3.1, R4.1, U1.9 (VCC), U2.9 (VCC), U3.9 (VCC), U4.9 (VCC), U5.9 (VCC), U6.9 (VCC), U7.9 (VCC), U8.9 (VCC), U9.9 (VCC), U10.9 (VCC), U11.9 (VCC), U12.9 (VCC), U13.9 (VCC), U14.9 (VCC), U15.9 (VCC), U16.9 (VCC)
V_{DD}: CN1.7, CN1.8, U1.8 (VDD), U2.8 (VDD), U3.8 (VDD), U4.8 (VDD), U5.8 (VDD), U6.8 (VDD), U7.8 (VDD), U8.8 (VDD), U9.8 (VDD), U10.8 (VDD), U11.8 (VDD), U12.8 (VDD), U13.8 (VDD), U14.8 (VDD), U15.8 (VDD), U16.8 (VDD)
V_{SS}: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.1, C10.1, C11.1, C12.1, C13.1, C14.1, C15.1, C16.1, CN1.1, CN1.2, CN2.3, CN2.10, CN2.13, CN2.20, U1.16 (VSS), U2.16 (VSS), U3.16 (VSS), U4.16 (VSS), U5.16 (VSS), U6.16 (VSS), U7.16 (VSS), U8.16 (VSS), U9.16 (VSS), U10.16 (VSS), U11.16 (VSS), U12.16 (VSS), U13.16 (VSS), U14.16 (VSS), U15.16 (VSS), U16.16 (VSS)

Notes on the sheet:
V_{BB} = -5V V_{CC} = +5V V_{DD} = +12V V_{SS} = GND

Board: 2 copper layers, 38 parts (0 on the bottom side), 32 nets.

## Commit log (part)

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2026-02-08 Design started
2026-02-09 Initial design completed
2026-02-11 Reproduction keyboard design started
2026-02-12 Keyboard switch photos
2026-02-12 Schematic updates
2026-02-12 Changed SPACE bar 6.25u->8.0u
2026-02-12 Initial design
2026-02-13 Keyboard design progress
2026-02-14 Keyboard progress
2026-02-15 Further updates
2026-02-18 Japan PSU photos
2026-02-22 Update design to use +15VDC in
